# Repository sensai7/CCVDrum

File README.md:

# CCVDrum
Energia code and Kicad files for a Korg Volca Drum MIDI CC board

In the Korg Volca Drum there's a hidden menu when you press the edit/step to 
change five adittional settings for each part and layer: bit resolution, 
overdrive, wave folding, pan, and pre-amp gain.

This repository contains the code, schematic, and PCB files to build and 
program a circuit board to control the 'hidden' paramenters from a Korg Volca 
Drum, having one dedicated knob control for each one and being able to select 
the first, second, or both layers with the provided push buttons. 
The circuit is based on a MSP430G2553, a common and cheap microprocessor from 
Texas Instruments, and it's coded in Energia, an Arduino port for TI 
processors, bringing the simplicity of the Wiring language and the huge 
Arduino community projects available to the Texas Instruments MCU ecosystem.

Some features:

* The board is designed to fit inside a 1590B enclosure, a really common 
and cheap enclosure model for guitar pedals.
* The power plug is a 2.1mm barrel jack and with the current Voltage Regulator 
model, Voltages from 5V to 20V are fine.
* There's a optional MIDI input to use as MIDI thru if you need to chain your 
devices.

The Volca must be [up to date](https://www.korg.com/us/support/download/product/0/809/#software), or at least in version 1.11 which changed a critical bug on the MIDI implementation (BIT knob won't work and the others would be changed). It must also be set in Split Channel Mode, the CC messages needed (BIT, DRV,... etc) are not available in the Single Channel Mode. My unit came with Split mode by default, but to check and change it, turn it on while holding ●RECORD, then press one of the channels to select it, then press it again to change it to channels 1-6. Press the ●RECORD button again when your unit's screen shows [MID 1--6](https://i.imgur.com/e5hpA2r.jpg).

The easiest way to flash a different firmware would be owning a MSP430G2 
(MSP-EXP430G2) launchpad, or the newer MSP430G2ET (MSP-EXP430G2ET) LaunchPad, 
place your MCU in the LaunchPad socket and flash the new code using Energia. 

Useful links

 * Korg Volca Drum official site: https://www.korg.com/us/products/dj/volca_drum/
 * Energia Project site: http://energia.nu
 * KiCad footprints and 3D models http://smisioto.no-ip.org/elettronica/kicad/kicad-en.htm

Datasheets

 * MSP430G2553 Mixed Signal Microcontroller http://www.ti.com/lit/ds/symlink/msp430g2553.pdf
 * 6N139 High Speed Optocoupler https://www.vishay.com/docs/83605/6n139.pdf
 * 74HC14 Hex inverting Schmitt trigger https://assets.nexperia.com/documents/data-sheet/74HC_HCT14.pdf
 * LM1117IMP-3.3 LDO Voltage Regulator http://www.ti.com/lit/ds/symlink/lm1117.pdf
 
 (Only in older versions):
 * AMS1117-3.3 1A LOW DROPOUT VOLTAGE REGULATOR http://www.advanced-monolithic.com/pdf/ds1117.pdf
 * 74AUP1G17 SINGLE SCHMITT-TRIGGER BUFFER https://www.diodes.com/assets/Datasheets/74AUP1G17.pdf

TODO

 * Fix minor bugs

## KiCad design THD/CCdrum.kicad_pcb

Schematic: CCdrum.sch

Parts:
C1, C4: 10; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2: 330; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3, C5: 100; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: 1N4148; diode_do35
D2: 1; LED_D3.0mm
D3: 2; LED_D3.0mm
D4: 3; LED_D3.0mm
D5: 4; LED_D3.0mm
D6: 5; LED_D3.0mm
D7: 6; LED_D3.0mm
J1: Barrel_Jack; BarrelJack_Horizontal
J4: MIDI_in; din-5
J5: MIDI_out; din-5
R1: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R8: 68; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R5, R7, R10, R11, R12: RLED; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 270; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2, RV3, RV4, RV5, RV6: 10k; trimmer_alps-rk09k1130ah1
SW1, SW2: SW_Push; SW_PUSH_6mm_H4.3mm
U1: MSP430G2533; DIP-20_W7.62mm
U2: LM1117IMP-3.3; TO-220-3_Horizontal_TabDown
U3: 6N139; DIP-8_W7.62mm
U4: 74HC14; DIP-14_W7.62mm

Connections:
+3V3: C3.1, C4.1, C5.1, R1.1, R2.1, R9.1, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, U1.1 (DVCC), U2.2 (VO), U3.8, U4.14
+5V: C2.1, J1.1, U2.3 (VI)
BIT: RV1.2, U1.2 (TA0CLK/ACLK/CA0/A0/P1.0)
DRV: RV3.2, U1.6 (TCK/SMCLK/UCB0STE/UCA0CLK/VREF+/VeREF+/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)
FLD: RV2.2, U1.5 (ADC10CLK/VREF-/VeREF-/A3/P1.3)
GAN: RV6.2, U1.14 (TDI/TCLK/TA0.1/UCB0SOMI/UCB0SCL/A6/P1.6)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), J1.2, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, SW1.1, SW2.1, U1.20 (DVSS), U2.1 (GND), U3.5, U4.7
LED_P1: R4.1, U1.13 (P2.5/TA1.2)
LED_P2: R5.1, U1.12 (P2.4/TA1.2)
LED_P3: R7.1, U1.11 (P2.3/TA1.0)
LED_P4: R10.1, U1.10 (P2.2/TA1.1)
LED_P5: R11.1, U1.9 (P2.1/TA1.1)
LED_P6: R12.1, U1.8 (P2.0/TA1.0)
unnamed: C1.1, R1.2, U1.16 (~RST~/NMI/SBWTDIO)
unnamed: D1.1, R3.1, U3.2
unnamed: D1.2, J4.5, U3.3
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: D4.2 (A), R7.2
unnamed: D5.2 (A), R10.2
unnamed: D6.2 (A), R11.2
unnamed: D7.2 (A), R12.2
unnamed: J4.4, R3.2
unnamed: J5.4, R2.2
unnamed: J5.5, R8.1
unnamed: R8.2, U4.8
unnamed: U4.6, U4.9
PAN: RV4.2, U1.7 (TMS/TA0.0/UCB0CLK/UCA0STE/A5/P1.5)
PART: RV5.2, U1.15 (TDO/TDI/UCB0SIMO/UCB0SDA/A7/P1.7)
PUSH_L1: SW1.2, U1.18 (P2.7/XOUT)
PUSH_L2: SW2.2, U1.19 (P2.6/XIN/TA0.1)
RXD: R9.2, U1.3 (TA0.0/UCA0RXD/UCA0SOMI/A1/P1.1), U3.6
TEST: U1.17 (TEST/SBWTCK)
TXD: U1.4 (TA0.1/UCA0TXD/UCA0SIMO/A2/P1.2), U4.5

Notes on the sheet:
check connections

Board: 2 copper layers, 106.0 x 54.5 mm, 38 parts (0 on the bottom side), 33 nets.

## KiCad design SMD and THD/CCdrum.kicad_pcb

Parts:
C1: 330; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2, C5: 100; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3: 1n; C_Disc_D5.0mm_W2.5mm_P5.00mm
C4: 10; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: 1; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: 2; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: 3; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: 4; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D5: 5; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: 6; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB_B_μ; conn_usb_B_micro_smd-2
J2: Program; PinHeader_1x04_P2.54mm_Vertical
J3: MIDI_out; din-5
R1: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R3, R4, R5, R6, R7: RLED; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R9: 68; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2, RV3, RV4, RV5, RV6: 10k; trimmer_alps-rk09k1130ah1
SW1, SW2: SW_Push; SW_PUSH_6mm_H4.3mm
U1: MSP430G2533; DIP-20_W7.62mm
U2: AMS1117-3.3; SOT-223-3_TabPin2
U3: 74AUP1G17; SOT-23-5_HandSoldering

Connections:
+3V3: C2.1, C4.1, C5.1, J2.1, R1.1, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, U1.20 (DVSS), U2.2 (VO)
+5V: C1.1, J1.1 (VBUS), U2.3 (VI)
BIT: RV1.2, U1.2 (TA0CLK/ACLK/CA0/A0/P1.0)
DRV: RV3.2, U1.6 (TCK/SMCLK/UCB0STE/UCA0CLK/VREF+/VeREF+/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)
FLD: RV2.2, U1.5 (ADC10CLK/VREF-/VeREF-/A3/P1.3)
GAN: RV5.2, U1.14 (TDI/TCLK/TA0.1/UCB0SOMI/UCB0SCL/A6/P1.6)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J1.5 (GND), J1.6 (Shield), J2.4, R9.2, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, SW1.1, SW2.1, U1.1 (DVCC), U2.1 (GND), U3.3 (GND)
LED_P1: R2.1, U1.13 (P2.5/TA1.2)
LED_P2: R3.1, U1.12 (P2.4/TA1.2)
LED_P3: R4.1, U1.11 (P2.3/TA1.0)
LED_P4: R5.1, U1.10 (P2.2/TA1.1)
LED_P5: R6.1, U1.9 (P2.1/TA1.1)
LED_P6: R7.1, U1.8 (P2.0/TA1.0)
unnamed: C3.1, R1.2, R10.2
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R3.2
unnamed: D3.2 (A), R4.2
unnamed: D4.2 (A), R5.2
unnamed: D5.2 (A), R6.2
unnamed: D6.2 (A), R7.2
unnamed: J3.4, R9.1
unnamed: J3.5, R8.1
unnamed: R8.2, U3.4
PAN: RV4.2, U1.7 (TMS/TA0.0/UCB0CLK/UCA0STE/A5/P1.5)
PART: RV6.2, U1.15 (TDO/TDI/UCB0SIMO/UCB0SDA/A7/P1.7)
PUSH_L1: SW1.2, U1.18 (P2.7/XOUT)
PUSH_L2: SW2.2, U1.19 (P2.6/XIN/TA0.1)
RST: J2.3, R10.1, U1.16 (~RST~/NMI/SBWTDIO)
RXD: U1.3 (TA0.0/UCA0RXD/UCA0SOMI/A1/P1.1)
TEST: J2.2, U1.17 (TEST/SBWTCK)
TXD: U1.4 (TA0.1/UCA0TXD/UCA0SIMO/A2/P1.2), U3.2
VCC: U3.5 (VCC)

Board: 2 copper layers, 100.0 x 37.4 mm, 35 parts (0 on the bottom side), 30 nets.

## Code that names these connections

File CCVDrum.ino:

// Pin connections
// Complete pinmap on http://energia.nu/pinmaps/img/LaunchPadMSP430G2452-v1.5.jpg
#define POT_BIT 2
#define POT_FLD 5
#define POT_DRV 6
#define POT_PAN 7
#define POT_GAN 14
#define POT_PART 15
#define LED_P1 13
#define LED_P2 12
#define LED_P3 11
#define LED_P4 10
#define LED_P5 9
#define LED_P6 8
#define PUSH_L1 18
#define PUSH_L2 19

//operation variables
const unsigned int numReadings = 10;
const unsigned int potPort[6] = {POT_PART, POT_BIT, POT_FLD, POT_DRV, POT_PAN, POT_GAN};
const unsigned int ledPort[6] = {LED_P1, LED_P2, LED_P3, LED_P4, LED_P5, LED_P6};
const unsigned int pushPort[2] = {PUSH_L1, PUSH_L2};
const unsigned int CCValues[5] = {0x31, 0x32, 0x33, 0x0A, 0x34}; //BIT, FLD, DRV, PAN, GAN //Complete Midi implementation on https://www.korg.com/us/support/download/product/0/809/
unsigned int readings[6][numReadings];
unsigned int readIndex = 0;
unsigned int total[6] = {0, 0, 0, 0, 0};
unsigned int average[6] = {0, 0, 0, 0, 0};
unsigned int outputValue[6] = {0, 0, 0, 0, 0};
unsigned int previousValue[6] = {0, 0, 0, 0, 0};
unsigned int part = 0;
unsigned int layer = 0;
bool push[2] = {1, 1};
bool previousPush[2] = {1, 1};
bool pushFlag = 0;

//timing variables
unsigned long previousMillis = 0;
const unsigned int interval = 10; //(milliseconds for each midi send)

void setup(){
	Serial.begin(31250); 

	//Setup LEDs
	for (int i = 0; i < 6; i++){
		pinMode(ledPort[i], OUTPUT);
		digitalWrite(ledPort[i], LOW);
	}

	//Read pot initial status
	for (int j = 0; j < numReadings; j++) {
		digitalWrite(ledPort[j%6], HIGH);
		for (int i = 0; i < 6; i++){
			readings[i][j] = analogRead(potPort[i]);
			total[i] += readings[i][j];
		}
		delay(50); 
		digitalWrite(ledPort[j%6], LOW);
		delay(50);
	} 

	//Setup buttons
//	P2SEL = 0;
//	P2DIR = BIT6+BIT7; //setup XIN and XOUT as digital outputs
//	pinMode(PUSH_L1, INPUT_PULLUP);
//	pinMode(PUSH_L2, INPUT_PULLUP);
}

void loop(){
	//Averaging and updating pot status
	for (int i = 0; i < 6; i++){
		average[i] = total[i] / numReadings;
		outputValue[i] = average[i] >> 3;
		total[i] -= readings[i][readIndex];
		readings[i][readIndex] = analogRead(potPort[i]);
		total[i] += readings[i][readIndex];
	}
	readIndex = (readIndex + 1) % (numReadings);

	// to be executed once every 'interval' miliseconds
	unsigned long currentMillis = millis();
	if (currentMillis - previousMillis > interval){	 
		previousMillis = currentMillis;

		//pots
		part = map(outputValue[0], 0, 127, 5, 0);
		for (int i = 1; i < 6; i++){
			if (outputValue[i] != previousValue[i]){
				digitalWrite(ledPort[i], HIGH);
				Serial.write(0xB0 + part); 
				Serial.write(CCValues[i - 1]);
				Serial.write(127 - outputValue[i]);
				previousValue[i] = outputValue[i];
				digitalWrite(ledPort[i], LOW);
			}
		}

//		//Buttons
//		for (int i = 0; i < 2; ++i){
//			previousPush[i] = push[i];
//			push[i] = digitalRead(pushPort[i]);
//		}
//		if (!push[0] && !push[1]){
//			pushFlag = 1;
//		}
//		if (!pushFlag){ //only one button
//			if (push[0] && !previousPush[0]){
//				Serial.write(0xB0 + part);
//				Serial.write(14);
//				Serial.write(0xff);
//			}
//			if (push[1] && !previousPush[1]){
//				Serial.write(0xB0 + part);
//				Serial.write(15);
//				Serial.write(0xff);
//			}
//		}
//		else{ // both buttons
//			if(push[0] | push[1] == 0){
//				pushFlag = 0;
//				Serial.write(0xB0 + part);
//				Serial.write(16);
//				Serial.write(0xff);
//			}
//		}

		//LEDs
//		if (!push[0] | !push[1]){
//			if(!push[0] | pushFlag){
//				digitalWrite(ledPort[0], HIGH);
//				digitalWrite(ledPort[1], HIGH);
//				digitalWrite(ledPort[2], HIGH);
//			}
//			if (!push[1] | pushFlag){
//				digitalWrite(ledPort[3], HIGH);
//				digitalWrite(ledPort[4], HIGH);
//				digitalWrite(ledPort[5], HIGH);
//			}
//		}
//		else{
			for (int i = 0; i < 6; i++){
				if (i != part){
					digitalWrite(ledPort[i], LOW);
				}
			}
			digitalWrite(ledPort[part], HIGH);
//		}

	} 
}

## Commit log

2019-03-20 Create CCVDrum.ino
    First commit
2019-03-20 Added KiCad Project
2019-03-20 Made the code more friendly and minor changes
2019-03-21 Changed 3D models
2019-03-23 code cleanup
2019-03-24 removed backups
2019-03-25 Re-annotated components
2019-03-25 Added a BOM table
2019-03-25 removed BOM TODO
2019-03-26 small optimization
2019-03-27 Added MIDI Channel selection
2019-03-29 Midi implementation released
2019-03-30 New Schematic
2019-03-30 New PCB Arrangement
2019-03-30 PCB Routed
2019-03-31 Added Decoupling caps
2019-03-31 New PCB design
2019-03-31 USB changed, small errors on board
2019-04-01 Code for the V0.2 board
2019-04-02 Updated BOM
2019-04-02 Removed comment text
2019-04-02 Fixed small stuff
2019-04-02 added button detection
2019-04-02 push buttons change layers via CC
2019-04-03 setup XIN and XOUT pins
2019-04-15 1590B 0.3 version added
2019-04-15 removed mask from screw holes
2019-04-16 Updated silkscreen + debug
2019-04-17 changed buffer
2019-04-21 Changed the MIDI out pullup resistor
2019-04-25 Fixed the mcu supply
2019-04-30 Added some more details
2019-05-07 Removed confusing information from the BOM and updated it a little
2019-05-07 First tested version
